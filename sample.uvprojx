# Keil uVision project sample.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCLANG5)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sample
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup_file
    ./startup_file/: startup_LPC17xx.s
  group main
    ./src/: main.c
  group lib_SoC_board
    ./lib_SoC_board/: core_cm3.c system_LPC17xx.c
  group timer
    ./src/timers/: IRQ_timer.c lib_timer.c timer.h
  group GLCD
    ./GLCD/: AsciiLib.c AsciiLib.h GLCD.c GLCD.h HzLib.c HzLib.h
  group utils
    ./src/utils/: game_utils.h LCD_utils.c LCD_utils.h structs.h game_utils.c timers_utils.h timers_utils.c CAN_utils.c CAN_utils.h
  group button
    ./src/buttons/: buttons.c buttons.h IRQ_buttons.c
  group RIT
    ./src/RIT/: IRQ_RIT.c lib_RIT.c RIT.h
  group joystick
    ./src/joystick/: joystick.c joystick.h
  group CAN
    ./src/CAN/: lib_CAN.c CAN.h CAN_callbacks.c IRQ_CAN.c
software components: CMSIS:CORE 5.4.0
